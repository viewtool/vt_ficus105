# Keil uVision project ficus_application.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F105VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ficus_application
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_CL,USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\Include;..\USER\USART;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8020000 size 0x20000
  memory RVCT9: RAM 0x20008000 size 0x2000
  group User
    ../USER/: main.c stm32fxxx_it.c
  group VTLIB
    ../VTLIB/: ficus_f1_dll.lib
  group CIMIS
    ../CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_cl.s
    ../CMSIS/Device/ST/STM32F10x/Source/Templates/: system_stm32f10x.c
software components: CMSIS:CORE 5.2.0
